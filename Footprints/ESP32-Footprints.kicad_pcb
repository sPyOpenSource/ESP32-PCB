File: Footprints/ESP32-Footprints.kicad_pcb (KiCad board)
At the start: 2 copper layers, 1 part, among them U1 ESP32-WROOM

Commit message: save
Other:
- net class Default removed
